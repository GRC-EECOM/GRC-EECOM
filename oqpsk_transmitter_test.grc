options:
  parameters:
    generate_options: qt_gui
    id: oqpsk_transmitter_test
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: int
    out_type: complex
    symbol_table: '[1+1j,1-1j,-1+1j,-1-1j]'
  states: {}
- name: oqpsk_receiver_0
  id: oqpsk_receiver
  parameters:
    a: '0.35'
    fc: '1000'
    num_taps: '11'
    samp_rate: '32000'
    sym_rate: '160'
  states: {}
- name: oqpsk_receiver_v5_0
  id: oqpsk_receiver_v5
  parameters:
    a: '0.35'
    fc: '1000'
    freq_offset: '0'
    num_taps: '11'
    samp_rate: '32000'
    sym_rate: '160'
    time_offset: '10'
  states: {state: disabled}
- name: oqpsk_transmitter_0
  id: oqpsk_transmitter
  parameters:
    a: '0.35'
    fc: '1000'
    num_taps: '11'
    samp_rate: '32000'
    sps: '200'
    sym_rate: '160'
  states: {}
- name: oqpsk_transmitter_v2_0
  id: oqpsk_transmitter_v2
  parameters:
    a: '0.35'
    fc: '1000'
    num_taps: '11'
    samp_rate: '32000'
    sps: '200'
    sym_rate: '160'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', oqpsk_transmitter_0, '0']
- [oqpsk_receiver_0, '0', qtgui_time_sink_x_0, '0']
- [oqpsk_transmitter_0, '0', oqpsk_receiver_0, '0']
- [oqpsk_transmitter_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
