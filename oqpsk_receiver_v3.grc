options:
  parameters:
    generate_options: hb
    id: oqpsk_receiver_v3
    output_language: python
  states: {}

blocks:
- name: a
  id: parameter
  parameters:
    value: '0.35'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-fc'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-fc'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    value: '1000'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: num_taps
  id: parameter
  parameters:
    value: '11'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: root_raised_cosine_filter_0_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: a
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_1_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: a
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '32000'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    value: '160'
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_add_xx_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0, '1']
- [blocks_complex_to_imag_1, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_real_1, '0', root_raised_cosine_filter_0_1_0_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', root_raised_cosine_filter_0_1_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_xx_1_0, '0', blocks_complex_to_imag_1, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_1, '1']
- [hilbert_fc_0, '0', blocks_multiply_xx_1_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']
- [root_raised_cosine_filter_0_1_0, '0', blocks_float_to_complex_0, '1']
- [root_raised_cosine_filter_0_1_0_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
