options:
  parameters:
    generate_options: qt_gui
    id: oqpsk_transmitter_v2
    output_language: python
  states: {}

blocks:
- name: a
  id: parameter
  parameters:
    value: '0.35'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(sps/2)
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/sym_rate)
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fc
  id: parameter
  parameters:
    value: '1000'
  states: {}
- name: num_taps
  id: parameter
  parameters:
    value: '11'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: a
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: a
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: parameter
  parameters:
    value: '200'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    value: '160'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_imag_0, '0', blocks_repeat_0, '0']
- [blocks_complex_to_real_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', blocks_throttle_1, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_delay_0, '0']
- [blocks_repeat_0_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_throttle_0, '0', blocks_repeat_0_0, '0']
- [blocks_throttle_1, '0', root_raised_cosine_filter_0_0, '0']
- [pad_source_0, '0', blocks_complex_to_imag_0, '0']
- [pad_source_0, '0', blocks_complex_to_real_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0_0, '1']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
